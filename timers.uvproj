# Keil uVision project timers.uvproj, settings and files
target timers (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: timers
  AfterMake: fromelf --bin --output .\rvmdk\timers.bin .\rvmdk\timers.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.2.111
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: timers.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S timers.c
    C:/ti/TivaWare_C_Series-2.1.2.111/utils/: uartstdio.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
